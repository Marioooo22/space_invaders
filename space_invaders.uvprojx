# Keil uVision project space_invaders.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: space_invaders
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  asm include: .\Objects
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./: main.c
  group common
    ./common/: bsp.h bsp.c
  group drivers
    ./drivers/: display.h display.c buttonD.c buttonD.h
  group tests
    ./tests/: testDisplay.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
